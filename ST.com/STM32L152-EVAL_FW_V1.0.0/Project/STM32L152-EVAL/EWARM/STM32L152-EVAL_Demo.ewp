# IAR project STM32L152-EVAL_Demo.ewp, settings and files
configuration STM32L152-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx\startup\iar; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Utilities\Third_Party\FatFs_vR0.08a; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL; ..\..\..\Utilities\STM32_EVAL\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_Demo.srec
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_i2c_tsensor.c stm32_eval_spi_sd.c
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval_glass_lcd.c stm32l152_eval_lcd.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: main.c menu.c stm32l1xx_it.c
