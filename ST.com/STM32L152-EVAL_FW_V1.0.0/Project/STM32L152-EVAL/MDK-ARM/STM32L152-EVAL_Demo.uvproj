# Keil uVision project STM32L152-EVAL_Demo.uvproj, settings and files
target STM32L152-EVAL_Demo (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD,USE_STM32L152_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\..\..\Utilities\Third_Party\FatFs_vR0.08a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../src/: stm32l1xx_it.c calendar.c main.c menu.c waveplayer.c storage.c iddmeasurement.c mass_storage.c usb_scsi.c hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c stm32l1xx_clock_config.c diskio.c
  group StdPeriph_Driver
    ../../../Libraries/stm32l1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group MDK-ARM
    ./: startup_stm32l1xx_md.s
  group CMSIS
    ../src/: system_stm32l1xx.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32L152-EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_spi_sd.c stm32_eval_i2c_tsensor.c
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval_glass_lcd.c stm32l152_eval_lcd.c
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Doc
    ../: readme.txt
